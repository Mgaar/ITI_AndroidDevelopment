## EmbeddedLinux/TASKS/buildrootcustompackage/Config.in
```kconfig
config BR2_PACKAGE_myapp
bool "myapp"

help
simple program that prints Hello World! 
```
